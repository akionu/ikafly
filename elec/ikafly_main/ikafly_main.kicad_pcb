# Repository akionu/ikafly

## KiCad design elec/ikafly_main/ikafly_main.kicad_pcb

Parts:
BT1: AA_Cell; Conn_MY-AA; LCSC C6937103
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1, J2: Motor_Conn; JST_ZH_2_Side
J3, J4: Nichrome_Conn; JST_ZH_2_Side

Connections:
/Ikafly_Motor1/OUT1: J1.1; also elsewhere on the board
/Ikafly_Motor1/OUT2: J1.2; also elsewhere on the board
/Ikafly_Motor2/OUT1: J2.1; also elsewhere on the board
/Ikafly_Motor2/OUT2: J2.2; also elsewhere on the board
/Ikafly_Nichrome1/OUT1: J3.1; also elsewhere on the board
/Ikafly_Nichrome1/OUT2: J3.2; also elsewhere on the board
/Ikafly_Nichrome2/OUT1: J4.1; also elsewhere on the board
/Ikafly_Nichrome2/OUT2: J4.2; also elsewhere on the board
/VBAT: BT1.1 (+); also elsewhere on the board
GND: BT1.2 (-); also elsewhere on the board

Parts:
AE2, AE3: ANT_315MHz; Pin_D1.0mm_L10.0mm
C27: 6.8p; C_0402_1005Metric; LCSC C1576
C28: 1.5p; C_0402_1005Metric; LCSC C1552
C29: 100n; C_0402_1005Metric; LCSC C83056
C30: 0.47u; C_0402_1005Metric; LCSC C123497
C31, C32, C34: 20p; C_0402_1005Metric; LCSC C1554
C33: 2.2u; C_0402_1005Metric; LCSC C12530
IC10: WF490RE; SOP-8_3.9x4.9mm_P1.27mm; LCSC C5182219
IC11: WF4455TD; SOT-23-6; LCSC C2886627
L2: 39nH; L_0402_1005Metric; LCSC C395063
L3: 68nH; L_0402_1005Metric; LCSC C90182
L4: 33nH; L_0402_1005Metric; LCSC C32837
L5: 3.3uH; L_0603_1608Metric; LCSC C963792
R16: 1k; R_0402_1005Metric; LCSC C2906899
R17: 100k; R_0402_1005Metric; LCSC C60491
R18: 10k; R_0402_1005Metric; LCSC C2906885
Y2: 9.844MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C648991

Connections:
/3V3: C29.1, C33.1, IC10.3 (VDD), IC11.5 (VDD), L5.1; also elsewhere on the board
/Ikafly_MCU/RF_RX: IC10.5 (DO); also elsewhere on the board
/Ikafly_MCU/RF_TX: R18.2; also elsewhere on the board
GND: C27.2, C29.2, C30.2, C32.2, C33.2, C34.2, IC10.1 (GND), IC10.6 (SHUT), IC11.2 (VSS), L2.2, L3.2, R17.2, Y2.2, Y2.4; also elsewhere on the board
unnamed: AE2.1 (A), C27.1, C28.1, L2.1
unnamed: AE3.1 (A), L4.1
unnamed: C31.1, L4.2
unnamed: C28.2, IC10.2 (ANT), L3.1
unnamed: C30.1, IC10.4 (CTH)
unnamed: C34.1, IC10.8 (RefOsc), R16.1, Y2.3
unnamed: IC11.4 (DIN), R17.1, R18.1
unnamed: C31.2, IC11.3 (PAOUT), L5.2
unnamed: IC11.6 (XIN), R16.2
unnamed: C32.1, IC11.1 (XOUT), Y2.1

Parts:
C1, C2: 20p; C_0402_1005Metric; LCSC C1554
C3, C6: 1u; C_0402_1005Metric; LCSC C5137485
C4, C5, C7, C8, C9, C10, C11, C12: 100n; C_0402_1005Metric; LCSC C83056
IC1: W25Q32JVZPIQ; SON127P600X500X80-9N-D; Manufacturer_Part_Number W25Q32JVZPIQ; LCSC C571260
IC2: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm; LCSC C2040
J5: GPS2MCU; GPS2MCU_Conn
R1, R2: 27; R_0402_1005Metric; LCSC C2909343
R3, R4: 1k; R_0402_1005Metric; LCSC C2906899
R5: 10k; R_0402_1005Metric; LCSC C2906885
R6: 1k; R_0402_1005Metric; LCSC C2906885
R7: DNF; R_0402_1005Metric; LCSC C2906885
R8, R9: 2.2k; R_0402_1005Metric; LCSC C2906920
S1: TS-1187A-B-A-B; TS1187ABAB; Manufacturer_Part_Number TS-1187A-B-A-B; LCSC C318884
Y1: Crystal_12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C133334

Connections:
/3V3: C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, IC1.8 (VCC), IC2.1 (IOVDD), IC2.10 (IOVDD), IC2.22 (IOVDD), IC2.33 (IOVDD), IC2.42 (IOVDD), IC2.43 (ADC_AVDD), IC2.44 (VREG_IN), IC2.48 (USB_VDD), IC2.49 (IOVDD), J5.1, R5.1, R8.1, R9.1; also elsewhere on the board
/Ikafly_Camera/D2: IC2.3 (GPIO1); also elsewhere on the board
/Ikafly_Camera/D3: IC2.4 (GPIO2); also elsewhere on the board
/Ikafly_Camera/D4: IC2.5 (GPIO3); also elsewhere on the board
/Ikafly_Camera/D5: IC2.6 (GPIO4); also elsewhere on the board
/Ikafly_Camera/D6: IC2.7 (GPIO5); also elsewhere on the board
/Ikafly_Camera/D7: IC2.8 (GPIO6); also elsewhere on the board
/Ikafly_Camera/D8: IC2.9 (GPIO7); also elsewhere on the board
/Ikafly_Camera/D9: IC2.11 (GPIO8); also elsewhere on the board
/Ikafly_Camera/EXCLK: IC2.2 (GPIO0); also elsewhere on the board
/Ikafly_Camera/HREF: IC2.13 (GPIO10); also elsewhere on the board
/Ikafly_Camera/PCLK: IC2.14 (GPIO11); also elsewhere on the board
/Ikafly_Camera/SCL: IC2.18 (GPIO15), R9.2; also elsewhere on the board
/Ikafly_Camera/SDA: IC2.17 (GPIO14), R8.2; also elsewhere on the board
/Ikafly_Camera/VSYNC: IC2.12 (GPIO9); also elsewhere on the board
/Ikafly_GNSS/BOOT: J5.5, R3.1, S1.A1 (COM_1), S1.B1 (COM_2); also elsewhere on the board
/Ikafly_GNSS/GNSS_PWR: IC2.35 (GPIO23), J5.6; also elsewhere on the board
/Ikafly_GNSS/LED: IC2.41 (GPIO29_ADC3), J5.7; also elsewhere on the board
/Ikafly_GNSS/MISO: IC2.16 (GPIO13), J5.3; also elsewhere on the board
/Ikafly_GNSS/MOSI: IC2.15 (GPIO12), J5.2; also elsewhere on the board
/Ikafly_MCU/1V1: C3.1, C4.1, C5.1, IC2.23 (DVDD), IC2.45 (VREG_VOUT), IC2.50 (DVDD)
/Ikafly_MCU/HEAT1: IC2.27 (GPIO16); also elsewhere on the board
/Ikafly_MCU/HEAT2: IC2.28 (GPIO17); also elsewhere on the board
/Ikafly_MCU/M1.PWMA: IC2.29 (GPIO18); also elsewhere on the board
/Ikafly_MCU/M1.PWMB: IC2.30 (GPIO19); also elsewhere on the board
/Ikafly_MCU/M2.PWMA: IC2.31 (GPIO20); also elsewhere on the board
/Ikafly_MCU/M2.PWMB: IC2.32 (GPIO21); also elsewhere on the board
/Ikafly_MCU/QSPI_SCLK: IC1.6 (CLK), IC2.52 (QSPI_SCLK)
/Ikafly_MCU/QSPI_SD0: IC1.5 (DI_(IO0)), IC2.53 (QSPI_SD0)
/Ikafly_MCU/QSPI_SD1: IC1.2 (DO_(IO1)), IC2.55 (QSPI_SD1)
/Ikafly_MCU/QSPI_SD2: IC1.3 (~WP_(IO2)), IC2.54 (QSPI_SD2)
/Ikafly_MCU/QSPI_SD3: IC1.7 (~RESET_(IO3)), IC2.51 (QSPI_SD3)
/Ikafly_MCU/QSPI_SS: IC1.1 (~CS), IC2.56 (QSPI_SS), R3.2, R5.2
/Ikafly_MCU/RF_RX: IC2.34 (GPIO22); also elsewhere on the board
/Ikafly_MCU/RF_TX: IC2.36 (GPIO24); also elsewhere on the board
/Ikafly_MCU/USB.D_N: R2.1; also elsewhere on the board
/Ikafly_MCU/USB.D_P: R1.1; also elsewhere on the board
/Ikafly_MCU/USB_BD_N: IC2.46 (USB_DM), R2.2
/Ikafly_MCU/USB_BD_P: IC2.47 (USB_DP), R1.2
/POWER: J5.8; also elsewhere on the board
/VBAT: R6.1; also elsewhere on the board
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, IC1.4 (GND), IC1.9 (EP), IC2.19 (TESTEN), IC2.57 (GND), J5.4, R7.2, S1.C1 (NO_1), S1.D1 (NO_2), Y1.2, Y1.4; also elsewhere on the board
unnamed: C1.2, R4.1, Y1.1
unnamed: IC2.38 (GPIO26_ADC0), R6.2, R7.1
unnamed: IC2.20 (XIN), R4.2
unnamed: C2.2, IC2.21 (XOUT), Y1.3

Notes on the sheet:
R6 -> 0Ω R7 -> DNF 想定されるVBATは1.6V(max, アルカリ乾電池)のため。

Parts:
JP2: Jumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm
Q4: Q_NMOS_GSD; SOT-23
R25: 1k; R_0402_1005Metric
R26: 10k; R_0402_1005Metric

Connections:
/Ikafly_MCU/HEAT1: R25.1; also elsewhere on the board
/Ikafly_Nichrome1/OUT1: Q4.3 (D); also elsewhere on the board
/Ikafly_Nichrome1/OUT2: JP2.2 (B); also elsewhere on the board
/VBAT: JP2.1 (A); also elsewhere on the board
GND: Q4.2 (S), R26.2; also elsewhere on the board
unnamed: Q4.1 (G), R25.2, R26.1

Parts of its further copies:
JP1: Jumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm
Q2: Q_NMOS_GSD; SOT-23
R19: 1k; R_0402_1005Metric
R20: 10k; R_0402_1005Metric

Connections of its further copies:
/Ikafly_MCU/HEAT2: R19.1; also elsewhere on the board
/Ikafly_Nichrome2/OUT1: Q2.3 (D); also elsewhere on the board
/Ikafly_Nichrome2/OUT2: JP1.2 (B); also elsewhere on the board
/VBAT: JP1.1 (A); also elsewhere on the board
GND: Q2.2 (S), R20.2; also elsewhere on the board
unnamed: Q2.1 (G), R19.2, R20.1

Parts:
J6: USB_type_C; LCSC C2874568
R10, R11: 5.1k; R_0402_1005Metric; LCSC C2906948

Connections:
/Ikafly_MCU/USB.D_N: J6.5 (B7_DN2), J6.7 (A7_DN1); also elsewhere on the board
/Ikafly_MCU/USB.D_P: J6.6 (A6_DP1), J6.8 (B6_DP2); also elsewhere on the board
/Ikafly_Power/VBUS_IN: J6.2 (A4-B9_VBUS), J6.11 (A9-B4_VBUS); also elsewhere on the board
GND: J6.1 (A1-B12_GND), J6.12 (A12-B1_GND), J6.S (SHIELD), R10.2, R11.2; also elsewhere on the board
unnamed: J6.4 (A5_CC1), R10.1
unnamed: J6.10 (B5_CC2), R11.1

Parts:
C35, C36: 10u; C_0603_1608Metric; LCSC C1691
C37, C38: 100u; C_1206_3216Metric
D3, D4: CUS10S30; D_SOD-323; LCSC C146335
F1: Polyfuse; Fuse_0603_1608Metric; LCSC C210357
IC12: XC6206P182MR; SOT-23-3; LCSC C347373
Q3: CJ2301-ES; SOT-23; LCSC C5224170
R21: 100k; R_0402_1005Metric; LCSC C60491
S2: MST22D18G2_125; MST22D18G2125; Manufacturer_Part_Number MST22D18G2 125; LCSC C2906280

Connections:
/3V3: C37.1, C38.1, Q3.3 (D); also elsewhere on the board
/Ikafly_Power/Ikafly_Power_DCDC_Logic/VIN: D3.1 (K), D4.1 (K), F1.2; also elsewhere on the board
/Ikafly_Power/Ikafly_Power_DCDC_Logic/VOUT: Q3.2 (S), R21.1; also elsewhere on the board
/Ikafly_Power/VBUS_IN: C35.1, IC12.3 (VI); also elsewhere on the board
/POWER: Q3.1 (G), R21.2, S2.3; also elsewhere on the board
/VBAT: F1.1; also elsewhere on the board
GND: C35.2, C36.2, C37.2, C38.2, D3.2 (A), IC12.1 (GND), S2.2; also elsewhere on the board
unnamed: C36.1, D4.2 (A), IC12.2 (VO)

Notes on the sheet:
Logic
Reverse Polarity Protection
V_USB(5V) => 1.8V
1.3～1.6V CUS10S30のVF=0.2～0.5V

Parts:
C17, C18, C19, C20, C21, C22: 10u; C_0603_1608Metric; LCSC C1691
IC5: ME6211C28M5G-N; SOT95P282X145-5N; Manufacturer_Part_Number ME6211C28M5G; LCSC C53099
IC6: ME6211C12M5G-N; SOT95P282X145-5N; Manufacturer_Part_Number ME6211C12M5G; LCSC C236672
J8: OV2640_FPC_P0.5_24P; FC05-SXXDCU-00; LCSC C2998872
R15: 10k; R_0402_1005Metric; LCSC C2906885

Connections:
/3V3: C17.1, C18.1, IC5.1 (VIN), IC5.3 (CE), IC6.1 (VIN), IC6.3 (CE); also elsewhere on the board
/Ikafly_Camera/1V2: C20.1, C22.1, IC6.5 (VOUT), J8.10 (DVDD)
/Ikafly_Camera/2V8: C19.1, C21.1, IC5.5 (VOUT), J8.4 (AVDD), J8.11 (DOVDD)
/Ikafly_Camera/D2: J8.19 (Y2); also elsewhere on the board
/Ikafly_Camera/D3: J8.21 (Y3); also elsewhere on the board
/Ikafly_Camera/D4: J8.22 (Y4); also elsewhere on the board
/Ikafly_Camera/D5: J8.20 (Y5); also elsewhere on the board
/Ikafly_Camera/D6: J8.18 (Y6); also elsewhere on the board
/Ikafly_Camera/D7: J8.16 (Y7); also elsewhere on the board
/Ikafly_Camera/D8: J8.14 (Y8); also elsewhere on the board
/Ikafly_Camera/D9: J8.12 (Y9); also elsewhere on the board
/Ikafly_Camera/EXCLK: J8.13 (MCLK); also elsewhere on the board
/Ikafly_Camera/HREF: J8.9 (HREF); also elsewhere on the board
/Ikafly_Camera/PCLK: J8.17 (PCLK); also elsewhere on the board
/Ikafly_Camera/SCL: J8.5 (SIO_C); also elsewhere on the board
/Ikafly_Camera/SDA: J8.3 (SIO_D); also elsewhere on the board
/Ikafly_Camera/VSYNC: J8.7 (VSYNC); also elsewhere on the board
GND: C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, IC5.2 (VSS), IC6.2 (VSS), J8.2 (AGND), J8.15 (DGND), R15.1; also elsewhere on the board
unnamed: J8.8 (PWDN), R15.2

Notes on the sheet:
1V2
2V8
DVDD: 1.2V DOVDD, AVDD: 2.8V

Parts:
AE1: ANT_GNSS; BWGNSCNX18-18W2; LCSC C2826453
BT2: CR2032; MY-2032-08-J-Fe; LCSC C19184094
C13: 470p; C_0402_1005Metric; LCSC C1537
C14, C15: 100n; C_0402_1005Metric; LCSC C83056
C16: 10u; C_0603_1608Metric; LCSC C1691
D1, D2: LED; LED_0603_1608Metric; LCSC C965807
H5, H6, H7, H8: MountingHole; MountingHole_2.2mm_M2
IC3: AT2659; LCSC C92450
IC4: ATGM336H-5N31; ATGM336H5N31; Manufacturer_Part_Number ATGM336H-5N31; LCSC C90770
J7: GPS2MCU; GPS2MCU_Conn
L1: 6.8nH; L_0402_1005Metric; LCSC C395075
Q1: CJ2301-ES; SOT-23; LCSC C5224170
R12: 100k; R_0402_1005Metric; LCSC C60491
R13, R14: 10k; R_0402_1005Metric; LCSC C2906885

Connections:
/3V3: C16.1, J7.1, Q1.2 (S), R12.1, R14.1; also elsewhere on the board
/Ikafly_GNSS/1PPS: IC4.4 (1PPS)
/Ikafly_GNSS/3V3_GNSS: C14.1, C15.1, IC3.4 (VDD), IC3.5 (~STDN), IC4.8 (VCC), Q1.3 (D)
/Ikafly_GNSS/BOOT: J7.5; also elsewhere on the board
/Ikafly_GNSS/GNSS_PWR: J7.6, Q1.1 (G), R12.2; also elsewhere on the board
/Ikafly_GNSS/LED: J7.7, R13.1; also elsewhere on the board
/Ikafly_GNSS/MISO: IC4.2 (TXD), J7.3; also elsewhere on the board
/Ikafly_GNSS/MOSI: IC4.3 (RXD), J7.2; also elsewhere on the board
/POWER: J7.8; also elsewhere on the board
GND: BT2.2 (-), C14.2, C15.2, C16.2, D1.1 (K), D2.1 (K), IC3.1 (GND), IC3.2 (GND), IC4.1 (GND_1), IC4.10 (GND_2), IC4.12 (GND_3), J7.4; also elsewhere on the board
unnamed: AE1.1 (A), C13.1
unnamed: BT2.1 (+), IC4.6 (VBAT)
unnamed: C13.2, L1.1
unnamed: D1.2 (A), R13.2
unnamed: D2.2 (A), R14.2
unnamed: IC3.3 (RFIN), L1.2
unnamed: IC3.6 (RFOUT), IC4.11 (RF_IN)

Notes on the sheet:
nRESET: Module reset input, low level effectively, Left floating when not in use ON/OFF: Shutoff control of module, low level effectively VCC_RF: ＋3.3V，Power supply for antenna
+: 1 -: 2

Schematic: ikafly_sensor.kicad_sch

Parts:
C23, C24, C25, C26: 100n; C_0402_1005Metric; LCSC C83056
IC7: LSM6DS3TR-C; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y; Manufacturer_Part_Number LSM6DS3TR-C; LCSC C967633
IC8: LIS3MDLTR; LGA-12_2x2mm_P0.5mm; LCSC C478483
IC9: SPL06-001; Goertek_SPL06-001; LCSC C2684428

Connections:
/3V3: C23.2, C25.1, C26.1, IC7.5 (VDDIO), IC7.8 (VDD), IC7.12 (CS), IC8.5 (Vdd), IC8.6 (Vdd_IO), IC8.10 (CS), IC9.6 (VDDIO), IC9.8 (VDD); also elsewhere on the board
/Ikafly_Camera/SCL: IC7.13 (SCL), IC8.1 (SCL), IC9.4 (SCL); also elsewhere on the board
/Ikafly_Camera/SDA: IC7.14 (SDA), IC8.11 (SDA_SDI_SDO), IC9.3 (SDA); also elsewhere on the board
GND: C23.1, C24.1, C25.2, C26.2, IC7.1 (ADO/SA0), IC7.2 (SDX), IC7.3 (SCX), IC7.6 (GND_1), IC7.7 (GND_2), IC8.2 (Reserved), IC8.3 (GND), IC8.9 (SDO_SA1), IC8.12 (Reserved), IC9.1 (GND), IC9.7 (GND); also elsewhere on the board
unnamed: C24.2, IC8.4 (C1)

Notes on the sheet:
I2C Address(7bit): 0x77
3-axis Magnetometer
I2C Address(7bit): 0x1C
3-axis Accelerometer & Gyroscope
I2C Address(7bit): 0x6A
Bus
Pressure

Schematic: ikafly_motor.kicad_sch

Parts:
C44, C45: 100n; C_0402_1005Metric; LCSC C83056
IC13: DRV8837; WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; LCSC C39159
R27: 10k; R_0402_1005Metric; LCSC C2906885

Connections:
/3V3: C44.1, IC13.8 (VCC), R27.1; also elsewhere on the board
/Ikafly_MCU/M1.PWMA: IC13.6 (IN1); also elsewhere on the board
/Ikafly_MCU/M1.PWMB: IC13.5 (IN2); also elsewhere on the board
/Ikafly_Motor1/OUT1: IC13.2 (OUT1); also elsewhere on the board
/Ikafly_Motor1/OUT2: IC13.3 (OUT2); also elsewhere on the board
/VBAT: C45.1, IC13.1 (VM); also elsewhere on the board
GND: C44.2, C45.2, IC13.4 (GND), IC13.9 (GND); also elsewhere on the board
unnamed: IC13.7 (~SLEEP), R27.2

Parts of its further copies:
C46, C47: 100n; C_0402_1005Metric; LCSC C83056
IC14: DRV8837; WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; LCSC C39159
R28: 10k; R_0402_1005Metric; LCSC C2906885

Connections of its further copies:
/3V3: C46.1, IC14.8 (VCC), R28.1; also elsewhere on the board
/Ikafly_MCU/M2.PWMA: IC14.6 (IN1); also elsewhere on the board
/Ikafly_MCU/M2.PWMB: IC14.5 (IN2); also elsewhere on the board
/Ikafly_Motor2/OUT1: IC14.2 (OUT1); also elsewhere on the board
/Ikafly_Motor2/OUT2: IC14.3 (OUT2); also elsewhere on the board
/VBAT: C47.1, IC14.1 (VM); also elsewhere on the board
GND: C46.2, C47.2, IC14.4 (GND), IC14.9 (GND); also elsewhere on the board
unnamed: IC14.7 (~SLEEP), R28.2

Schematic: ikafly_power_1v5cell_to_3v3.kicad_sch

Parts:
C39, C40, C41, C42, C43: 22u; C_0603_1608Metric; LCSC C59461
L6: 1.5uH; L_Sunlord_SWPA3015S; LCSC C5159663
PS1: PAM2401SCADJ; SOP65P490X110-8N; Manufacturer_Part_Number PAM2401SCADJ; LCSC C508238
R22: 10k; R_0402_1005Metric; LCSC C2906885
R23: 680k; R_0402_1005Metric; LCSC C2909377
R24: 150k; R_0402_1005Metric; LCSC C2909320

Connections:
/Ikafly_Power/Ikafly_Power_DCDC_Logic/VIN: C39.1, C40.1, L6.1, PS1.3 (VIN), R22.1; also elsewhere on the board
/Ikafly_Power/Ikafly_Power_DCDC_Logic/VOUT: C41.1, C42.1, C43.1, PS1.7 (OUT), R23.1; also elsewhere on the board
GND: C39.2, C40.2, C41.2, C42.2, C43.2, PS1.4 (AGND), PS1.8 (PGND), R24.2; also elsewhere on the board
unnamed: PS1.2 (EN), R22.2
unnamed: PS1.5 (FB), R23.2, R24.1
unnamed: L6.2, PS1.1 (LX)

Notes on the sheet:
Low ESR
V_BAT(0.9-1.2V) => 3.3V
